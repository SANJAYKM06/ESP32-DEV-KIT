# Repository SANJAYKM06/ESP32-DEV-KIT

File README.md:

# ESP32-DEV-KIT
his project is a custom PCB design of the ESP32 DevKit, created using KiCad 9

## KiCad design esp32 dev kit/esp32devkit.kicad_pcb

Parts:
C1, C3, C21: 22µF/10V(20%); C_0201_0603Metric
C9, C14, C19, C22: 0.1µF/50V(10%); C_01005_0402Metric
C15: 0.1µf/50v(10%)(NC); C_01005_0402Metric
C20: 4.7µF/0.3V(10%); C_01005_0402Metric
D1: LED; LED_0603_1608Metric
D3: D_Schottky; D_SOD-323
D4, D5, D6: D_TVS; D_SOD-523
J1: USB_B_Micro; USB_Micro-AB_Molex_47590-0001
J2, J3: Conn_01x19_Pin; PinSocket_1x19_P2.54mm_Vertical
MOD1: ESP32-WROOM-32; ESP32-WROOM-32D
Q1, Q2: MMSS8050-H-TP; SOT-23-3; MPN MMSS8050-H-TP; Digi-Key_PN MMSS8050-H-TPMSCT-ND
R2, R24: 2KΩ (5%); R_01005_0402Metric
R11, R21, R22: 10KΩ(5%); R_01005_0402Metric
R17, R18: 0R(5%); R_01005_0402Metric
R23: 10KΩ(5%)(NC); R_01005_0402Metric
R25: 22.1KΩ(5%); R_01005_0402Metric
R26: 47.5KΩ(5%); R_01005_0402Metric
SW1, SW2: SW_Push; SW_SPST_B3S-1000
U1: CP2102N-Axx-xQFN28; TQFN-28-1EP_5x5mm_P0.5mm_EP2.7x2.7mm
U2: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
/CDC: U1.1 (~DCD)
/CLK: J3.19, MOD1.20 (SCK/CLK)
/CMD: J2.18, MOD1.19 (SCS/CMD)
/CTS: U1.23 (~CTS)
/DSR: U1.27 (~DSR)
/DTR: Q2.3 (C), R21.1, U1.28 (~DTR)
/EN: C9.1, J2.2, MOD1.3 (EN), Q1.3 (C), R11.2
/EXT_5V: C1.1, D3.1 (K), J2.19, R2.1, U2.3 (VI)
/IO0: J3.14, MOD1.25 (IO0), Q2.2 (E)
/IO2: J3.15, MOD1.24 (IO2)
/IO4: J3.13, MOD1.26 (IO4)
/IO5: J3.10, MOD1.29 (IO5)
/IO12: J2.13, MOD1.14 (IO12)
/IO13: J2.15, MOD1.16 (IO13)
/IO14: J2.12, MOD1.13 (IO14)
/IO15: J3.16, MOD1.23 (IO15)
/IO16: J3.12, MOD1.27 (IO16)
/IO17: J3.11, MOD1.28 (IO17)
/IO18: J3.9, MOD1.30 (IO18)
/IO19: J3.8, MOD1.31 (IO19)
/IO21: J3.6, MOD1.33 (IO21)
/IO22: J3.3, MOD1.36 (IO22)
/IO23: J3.2, MOD1.37 (IO23)
/IO25: J2.9, MOD1.10 (IO25)
/IO26: J2.10, MOD1.11 (IO26)
/IO27: J2.11, MOD1.12 (IO27)
/IO32: J2.7, MOD1.8 (IO32)
/IO33: J2.8, MOD1.9 (IO33)
/IO34: J2.5, MOD1.6 (IO34)
/IO35: J2.6, MOD1.7 (IO35)
/RI: U1.2 (~RI/CLK)
/RTS: Q1.2 (E), R22.1, U1.24 (~RTS)
/RXD: R17.2, U1.25 (RXD)
/RXDO: J3.5, MOD1.34 (RXD0/IO3), R18.1
/SD0: J3.18, MOD1.21 (SDO/SD0)
/SD1: J3.17, MOD1.22 (SDI/SD1)
/SD2: J2.16, MOD1.17 (SHD/SD2)
/SD3: J2.17, MOD1.18 (SWP/SD3)
/SENSOR_VN: J2.4, MOD1.5 (SENSOR_VN)
/SENSOR_VP: J2.3, MOD1.4 (SENSOR_VP)
/TXD: R18.2, U1.26 (TXD)
/TXDO: J3.4, MOD1.35 (TXD0/IO1), R17.1
/USB_DN: D4.2 (A2), J1.2 (D-), U1.5 (D-)
/USB_DP: D5.2 (A2), J1.3 (D+), U1.4 (D+)
/VBUS: D3.2 (A), D6.1 (A1), J1.1 (VBUS), R25.1
/VDD33: C3.1, C19.1, C20.1, C21.1, C22.1, J2.1, MOD1.2 (VDD), R11.1, R24.1, U1.6 (VDD), U1.7 (VREGIN), U2.2 (VO)
GND: C1.2, C3.2, C9.2, C14.1, C15.1, C19.2, C20.2, C21.2, C22.2, D1.1 (K), D4.1 (A1), D5.1 (A1), D6.2 (A2), J1.5 (GND), J1.6 (Shield), J2.14, J3.1, J3.7, MOD1.1 (GND), MOD1.15 (GND), MOD1.38 (GND), MOD1.39 (GND), R23.2, R26.2, SW1.1, SW2.1, U1.3 (GND), U1.29 (GND), U2.1 (GND)
unnamed: C14.2, SW2.2
unnamed: C15.2, SW1.2
unnamed: D1.2 (A), R2.2
unnamed: Q1.1 (B), R21.2
unnamed: Q2.1 (B), R22.2
unnamed: R25.2, R26.1, U1.8 (VBUS)
unnamed: R24.2, U1.9 (~RST)
unnamed: R23.1, U1.11 (~SUSPEND)

Notes on the sheet:
Connectors
ESP32 module
Power Supply
Switch Button
Micro USB 7 USB-UART

Board: 4 copper layers, 48.9 x 59.5 mm, 34 parts (0 on the bottom side), 51 nets.
